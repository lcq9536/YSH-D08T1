# Keil uVision project YSH-D08E1.uvproj, settings and files
target Target 1 (MCS-51)
  device: SH79F3212 Sinowealth
  cpu: IRAM(0 - 0xFF) IROM(0-0x7FFF) XRAM(0-0x4FF) CLOCK(16600000)
  output: YSH-D08E1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\TouchKey
  link misc: REMOVEUNUSED
  group Source
    ./Source/: main.c Buzzer.c Digital.c Key.c NTC.c Triac.c Voltage.c Timer.c MCU.c LED.c Work.c
  group TouchKey
    ./TouchKey/: tk.LIB tk_cfg.c
